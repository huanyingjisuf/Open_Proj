# Keil uVision project ble_app_uart_s110_pca10028.uvproj, settings and files
target nrf51422_xxac_s110 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\bsp;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\drivers_nrf\twi_master\deprecated;..\..\..\..\..\..\components\drivers_nrf\twi_master\deprecated\config;..\..\..\..\..\..\components\drivers_nrf\twi_master;.\MPR121;.\W25Q32;.\BL5372;.\Devic_Init;.\Flash-RW;.\Moto_Run;.\Speak;.\ADC;.\NRF_WDT;.\KEY_Run;.\BLE_Data;.\Unix_Time;.\Pass_Word;..\..\..\..\..\..\components\drivers_ext\segger_rtt;..\..\..\..\..\..\uart_lib;..\..\..\..\..\..\components\drivers_nrf\spi_master;.\Act_PassWord;.\SK1311;.\SK1311\SourceCode;.\SK1311\SourceCode\driver;.\SK1311\SourceCode\iso14443;.\SK1311\SourceCode\sky1311;.\Uart_Run;.\NB_Mode1;.\F_print
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group W25Q32
    ./W25Q32/: W25Q32.C
  group BL5372
    ./BL5372/: BL5372.C
  group Devic_Init
    ./Devic_Init/: Devic_Init.c
  group Flash_RW
    ./Flash-RW/: Flash_RW.c
  group Moto_Run
    ./Moto_Run/: Moto_Run.c
  group Speak
    ./Speak/: speak.c
  group NRF_ADC
    ./ADC/: ADC.c
  group NRF_WDT
    ./NRF_WDT/: NRF_WDT.C
  group KEY_Run
    ./KEY_Run/: KEY_Run.c
  group BLE_Data
    ./BLE_Data/: BLE_Data.c
  group Unix_time
    ./Unix_Time/: Unix_Time.c
  group Pass_Word
    ./Pass_Word/: Pass_Word.c
  group nRF_Segger_RTT
    ../../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group uart_lib
    ../../../../../../uart_lib/: uart.c simple_uart.c
  group Act_PassWord
    ./Act_PassWord/: Act_PassWord.c
  group SKY1311
    ./SK1311/SourceCode/driver/: sky1311_drv.c stm8_eval.c
    ./SK1311/SourceCode/iso14443/: mifare1.c iso14443b.c iso14443a.c
    ./SK1311/SourceCode/sky1311/: sky1311t.c
    ./SK1311/SourceCode/: cardoper.c
  group MPR121
    ./MPR121/: MPR121.C
  group Uart_Run
    ./Uart_Run/: Uart_Run.c
  group NB_Mode
    ./NB_Mode1/: NB_Mode1.c
  group F_Print
    ./F_print/: F_print.c
target flash_s110_nrf51_8.0.0_softdevice (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: as above
  output: s110_nrf51_8.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
